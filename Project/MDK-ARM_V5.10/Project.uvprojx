# Keil uVision project Project.uvprojx, settings and files
target UCORTEX (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: auto_charge_mcu +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\..\FWLib_3_5_0\CMSIS\CM3\CoreSupport;..\..\FWLib_3_5_0\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\FWLib_3_5_0\STM32F10x_StdPeriph_Driver\inc;..\..\Project;..\..\Drives\LED;..\..\Drives\KEY;..\..\Common\DELAY;..\..\Drives\USART;..\..\Common;..\..\Drives\OLED;..\..\Drives\LCM1602;..\..\Drives\LCM12864;..\..\Drives\ADC;..\..\Drives\JOYSTICK;..\..\Drives\TIMER;..\..\Drives\RTC;..\..\Drives\EXTI;..\..\Drives\STANDBY;..\..\Drives\DMA;..\..\Drives\BEEP;..\..\Drives\EEPROM;..\..\Drives\SPI;..\..\Drives\NRF24L01;..\..\Drives\I2C;..\..\Drives\MPU6050;..\MDK-ARM_V5.10;.\RTE;..\..\VL6180_API_3.2.0_Extended_Range\config\extended_range;..\..\VL6180_API_3.2.0_Extended_Range\core\inc;..\..\VL6180_API_3.2.0_Extended_Range\example\code_samples;..\..\VL6180_API_3.2.0_Extended_Range\platform\cci-i2c;..\..\VL6180_API_3.2.0_Extended_Range\platform\template;..\..\Drives\CAN;..\..\Common\Platform
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group PROJECT
    ../: main.c stm32f10x_it.c system_stm32f10x.c
    ./: VL6180x.c remote.c switch.c global.c can_fifo.c tools.c can_protocol.c
  group DRIVERS
    ../../Drives/LED/: led.c
    ../../Drives/USART/: usart.c
    ../../Drives/TIMER/: timer.c
    ../../Drives/DMA/: dma.c
    ../../Drives/CAN/: can.c
    ../../Drives/I2C/: i2c.c
  group VL6180X
    ../../VL6180_API_3.2.0_Extended_Range/core/src/: vl6180x_api.c
    ../../VL6180_API_3.2.0_Extended_Range/platform/cci-i2c/: vl6180x_i2c.c
  group COMMON
    ../../Common/DELAY/: delay.c
    ../../Common/Platform/: platform.c
  group FWLib_3_5_0
    ../../FWLib_3_5_0/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_dma.c stm32f10x_can.c
  group CMSIS
    ../../FWLib_3_5_0/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../FWLib_3_5_0/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group DOC
    ../../: 例程说明.txt
software components: CMSIS:CORE 4.3.0
